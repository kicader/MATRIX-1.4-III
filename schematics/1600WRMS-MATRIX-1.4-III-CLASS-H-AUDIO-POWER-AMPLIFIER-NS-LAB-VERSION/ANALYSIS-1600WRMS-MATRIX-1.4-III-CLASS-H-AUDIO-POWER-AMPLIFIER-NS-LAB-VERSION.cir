.title ANALYSIS OF 1600W RMS MATRIX 1.4 III CLASS-H AUDIO POWER AMPLIFIER (LAB VERSION)
.include "spice_models/model.lib"
V1 +120V 0 120V DC
V2 0 -120V 120V DC
V3 +42V 0 42V DC
V4 0 -42V 42V DC
V6 +15V 0 15V DC
V7 0 -15V 15V DC
Rdummy3 M_OUT 0 100k
Rdummy1 /M_SP 0 4
SR701 M_OUT /M_SP +RLC -RLC sw1 ON
Rdummy2 +RLC -RLC 660
V5 M_INPUT 0 dc 0 ac 1.41 sin(0 1.414 1k 0 0)
Q501 Net-_Q501-Pad1_ Net-_Q501-Pad2_ +120V 2N5401
D606 Net-_D606-Pad1_ +120V 1N4742
D605 +42V Net-_C601-Pad2_ 1N4148
R5126 Net-_Q5086-Pad3_ /POWER_AMP_BLOCK/M_OUT_RAW 0.56
D607 +42V /POWER_AMP_BLOCK/M_VSWOP MURF1560
Q603 Net-_D606-Pad1_ Net-_Q603-Pad2_ +120V 2N5401
D604 Net-_C601-Pad1_ Net-_D604-Pad2_ 1N4148
Q602 Net-_Q602-Pad1_ Net-_Q602-Pad2_ +120V 2N5401
Q503 Net-_Q503-Pad1_ Net-_Q503-Pad2_ -120V 2N5551
D613 -120V Net-_D613-Pad2_ 1N4742
Q605 Net-_Q605-Pad1_ Net-_Q605-Pad2_ -120V 2N5551
D612 Net-_C602-Pad2_ -42V 1N4148
D611 Net-_D611-Pad1_ Net-_C602-Pad1_ 1N4148
Q606 Net-_D613-Pad2_ Net-_Q606-Pad2_ -120V 2N5551
D614 M_VSWON -42V MURF1560
R5156 /POWER_AMP_BLOCK/M_FPSSN Net-_Q5116-Pad3_ 100
Q5116 M_VSWON /POWER_AMP_BLOCK/M_DRV2N Net-_Q5116-Pad3_ 2SA1943
R5158 /POWER_AMP_BLOCK/M_FPSSN Net-_Q5118-Pad3_ 100
Q5118 M_VSWON /POWER_AMP_BLOCK/M_DRV2N Net-_Q5118-Pad3_ 2SA1943
R5159 /POWER_AMP_BLOCK/M_FPSSN Net-_Q5119-Pad3_ 100
Q5119 M_VSWON /POWER_AMP_BLOCK/M_DRV2N Net-_Q5119-Pad3_ 2SA1943
R51510 /POWER_AMP_BLOCK/M_FPSSN Net-_Q51110-Pad3_ 100
Q51110 M_VSWON /POWER_AMP_BLOCK/M_DRV2N Net-_Q51110-Pad3_ 2SA1943
Q5086 /POWER_AMP_BLOCK/M_VSWOP /POWER_AMP_BLOCK/M_DRV2P Net-_Q5086-Pad3_ 2SC5200
R5146 Net-_Q5086-Pad3_ /POWER_AMP_BLOCK/M_FPSSP 100
Q5088 /POWER_AMP_BLOCK/M_VSWOP /POWER_AMP_BLOCK/M_DRV2P Net-_Q5088-Pad3_ 2SC5200
R5148 Net-_Q5088-Pad3_ /POWER_AMP_BLOCK/M_FPSSP 100
Q5089 /POWER_AMP_BLOCK/M_VSWOP /POWER_AMP_BLOCK/M_DRV2P Net-_Q5089-Pad3_ 2SC5200
R5149 Net-_Q5089-Pad3_ /POWER_AMP_BLOCK/M_FPSSP 100
Q50810 /POWER_AMP_BLOCK/M_VSWOP /POWER_AMP_BLOCK/M_DRV2P Net-_Q50810-Pad3_ 2SC5200
R51410 Net-_Q50810-Pad3_ /POWER_AMP_BLOCK/M_FPSSP 100
R51210 Net-_Q50810-Pad3_ /POWER_AMP_BLOCK/M_OUT_RAW 0.56
R5129 Net-_Q5089-Pad3_ /POWER_AMP_BLOCK/M_OUT_RAW 0.56
R5128 Net-_Q5088-Pad3_ /POWER_AMP_BLOCK/M_OUT_RAW 0.56
R51310 /POWER_AMP_BLOCK/M_OUT_RAW Net-_Q51110-Pad3_ 0.56
R5139 /POWER_AMP_BLOCK/M_OUT_RAW Net-_Q5119-Pad3_ 0.56
R5138 /POWER_AMP_BLOCK/M_OUT_RAW Net-_Q5118-Pad3_ 0.56
R5136 /POWER_AMP_BLOCK/M_OUT_RAW Net-_Q5116-Pad3_ 0.56
R517 /POWER_AMP_BLOCK/M_OUT_RAW Net-_Q512-Pad2_ 820
D510 /POWER_AMP_BLOCK/M_VBIASP Net-_D510-Pad2_ 1N4148
Q512 Net-_D510-Pad2_ Net-_Q512-Pad2_ /POWER_AMP_BLOCK/M_OUT_RAW 2N5551
Q506 /POWER_AMP_BLOCK/M_VSWOP /POWER_AMP_BLOCK/M_VBIASP /POWER_AMP_BLOCK/M_DRV1P MJE15032
R5141 Net-_Q5081-Pad3_ /POWER_AMP_BLOCK/M_FPSSP 100
R5125 Net-_Q5085-Pad3_ /POWER_AMP_BLOCK/M_OUT_RAW 0.56
R5124 Net-_Q5084-Pad3_ /POWER_AMP_BLOCK/M_OUT_RAW 0.56
R5123 Net-_Q5083-Pad3_ /POWER_AMP_BLOCK/M_OUT_RAW 0.56
R5122 Net-_Q5082-Pad3_ /POWER_AMP_BLOCK/M_OUT_RAW 0.56
R5121 Net-_Q5081-Pad3_ /POWER_AMP_BLOCK/M_OUT_RAW 0.56
R519 /POWER_AMP_BLOCK/M_OUT_RAW Net-_Q513-Pad2_ 820
Q513 Net-_D511-Pad1_ Net-_Q513-Pad2_ /POWER_AMP_BLOCK/M_OUT_RAW 2N5401
D511 Net-_D511-Pad1_ /POWER_AMP_BLOCK/M_VBIASN 1N4148
Q509 M_VSWON /POWER_AMP_BLOCK/M_VBIASN /POWER_AMP_BLOCK/M_DRV1N MJE15033
R5151 /POWER_AMP_BLOCK/M_FPSSN Net-_Q5111-Pad3_ 100
Q5111 M_VSWON /POWER_AMP_BLOCK/M_DRV2N Net-_Q5111-Pad3_ 2SA1943
R5152 /POWER_AMP_BLOCK/M_FPSSN Net-_Q511-Pad3_ 100
Q511 M_VSWON /POWER_AMP_BLOCK/M_DRV2N Net-_Q511-Pad3_ 2SA1943
R5153 /POWER_AMP_BLOCK/M_FPSSN Net-_Q5113-Pad3_ 100
Q5113 M_VSWON /POWER_AMP_BLOCK/M_DRV2N Net-_Q5113-Pad3_ 2SA1943
R5154 /POWER_AMP_BLOCK/M_FPSSN Net-_Q5114-Pad3_ 100
Q5114 M_VSWON /POWER_AMP_BLOCK/M_DRV2N Net-_Q5114-Pad3_ 2SA1943
R5155 /POWER_AMP_BLOCK/M_FPSSN Net-_Q5115-Pad3_ 100
Q5115 M_VSWON /POWER_AMP_BLOCK/M_DRV2N Net-_Q5115-Pad3_ 2SA1943
Q5082 /POWER_AMP_BLOCK/M_VSWOP /POWER_AMP_BLOCK/M_DRV2P Net-_Q5082-Pad3_ 2SC5200
R5142 Net-_Q5082-Pad3_ /POWER_AMP_BLOCK/M_FPSSP 100
Q5083 /POWER_AMP_BLOCK/M_VSWOP /POWER_AMP_BLOCK/M_DRV2P Net-_Q5083-Pad3_ 2SC5200
R5143 Net-_Q5083-Pad3_ /POWER_AMP_BLOCK/M_FPSSP 100
Q5084 /POWER_AMP_BLOCK/M_VSWOP /POWER_AMP_BLOCK/M_DRV2P Net-_Q5084-Pad3_ 2SC5200
R5144 Net-_Q5084-Pad3_ /POWER_AMP_BLOCK/M_FPSSP 100
Q5085 /POWER_AMP_BLOCK/M_VSWOP /POWER_AMP_BLOCK/M_DRV2P Net-_Q5085-Pad3_ 2SC5200
R5145 Net-_Q5085-Pad3_ /POWER_AMP_BLOCK/M_FPSSP 100
R5135 /POWER_AMP_BLOCK/M_OUT_RAW Net-_Q5115-Pad3_ 0.56
R5134 /POWER_AMP_BLOCK/M_OUT_RAW Net-_Q5114-Pad3_ 0.56
R5133 /POWER_AMP_BLOCK/M_OUT_RAW Net-_Q5113-Pad3_ 0.56
R5132 /POWER_AMP_BLOCK/M_OUT_RAW Net-_Q511-Pad3_ 0.56
R5131 /POWER_AMP_BLOCK/M_OUT_RAW Net-_Q5111-Pad3_ 0.56
C501 /POWER_AMP_BLOCK/M_VBIASP /POWER_AMP_BLOCK/M_VBIASN 0.1uF
Q505 /POWER_AMP_BLOCK/M_VBIASP Net-_Q505-Pad2_ Net-_Q505-Pad3_ MJE340
R5137 /POWER_AMP_BLOCK/M_OUT_RAW Net-_Q5117-Pad3_ 0.56
R5127 Net-_Q5087-Pad3_ /POWER_AMP_BLOCK/M_OUT_RAW 0.56
R5147 Net-_Q5087-Pad3_ /POWER_AMP_BLOCK/M_FPSSP 100
Q5087 /POWER_AMP_BLOCK/M_VSWOP /POWER_AMP_BLOCK/M_DRV2P Net-_Q5087-Pad3_ 2SC5200
Q5117 M_VSWON /POWER_AMP_BLOCK/M_DRV2N Net-_Q5117-Pad3_ 2SA1943
R5157 /POWER_AMP_BLOCK/M_FPSSN Net-_Q5117-Pad3_ 100
R51311 /POWER_AMP_BLOCK/M_OUT_RAW Net-_Q51111-Pad3_ 0.56
R51211 Net-_Q50811-Pad3_ /POWER_AMP_BLOCK/M_OUT_RAW 0.56
R51411 Net-_Q50811-Pad3_ /POWER_AMP_BLOCK/M_FPSSP 100
Q50811 /POWER_AMP_BLOCK/M_VSWOP /POWER_AMP_BLOCK/M_DRV2P Net-_Q50811-Pad3_ 2SC5200
Q51111 M_VSWON /POWER_AMP_BLOCK/M_DRV2N Net-_Q51111-Pad3_ 2SA1943
R51511 /POWER_AMP_BLOCK/M_FPSSN Net-_Q51111-Pad3_ 100
R505 /POWER_AMP_BLOCK/M_VBIASP Net-_Q505-Pad2_ 820
D503 Net-_D502-Pad2_ Net-_C404-Pad2_ 1N4148
D502 Net-_D501-Pad2_ Net-_D502-Pad2_ 1N4148
D501 /POWER_AMP_BLOCK/M_VBIASP Net-_D501-Pad2_ 1N4148
D506 Net-_D505-Pad2_ /POWER_AMP_BLOCK/M_VBIASN 1N4148
D505 Net-_D504-Pad2_ Net-_D505-Pad2_ 1N4148
D504 Net-_C404-Pad2_ Net-_D504-Pad2_ 1N4148
Q504 /POWER_AMP_BLOCK/M_VBIASN Net-_Q503-Pad1_ Net-_Q503-Pad2_ MJE340
Q502 /POWER_AMP_BLOCK/M_VBIASP Net-_Q501-Pad1_ Net-_Q501-Pad2_ MJE350
RT501 Net-_R507-Pad2_ Net-_D507-Pad1_ 5k
D507 Net-_D507-Pad1_ /POWER_AMP_BLOCK/M_VBIASN 1N4004
R507 Net-_Q505-Pad2_ Net-_R507-Pad2_ 4.7k
R508 Net-_Q505-Pad3_ Net-_D507-Pad1_ 180
R506 Net-_Q505-Pad2_ Net-_D507-Pad1_ 1.2k
Q5081 /POWER_AMP_BLOCK/M_VSWOP /POWER_AMP_BLOCK/M_DRV2P Net-_Q5081-Pad3_ 2SC5200
L501 /POWER_AMP_BLOCK/M_OUT_RAW M_OUT 3uH
C502 Net-_C502-Pad1_ 0 0.1uF
X6022 M_VSWON Net-_D613-Pad2_ -120V IRF540
R511 /POWER_AMP_BLOCK/M_OUT_RAW /POWER_AMP_BLOCK/M_DRV2N 12
R510 /POWER_AMP_BLOCK/M_DRV2P /POWER_AMP_BLOCK/M_OUT_RAW 12
Q510 M_VSWON /POWER_AMP_BLOCK/M_DRV1N /POWER_AMP_BLOCK/M_DRV2N 2SA1943
R518 Net-_Q513-Pad2_ /POWER_AMP_BLOCK/M_FPSSN 10k
Q507 /POWER_AMP_BLOCK/M_VSWOP /POWER_AMP_BLOCK/M_DRV1P /POWER_AMP_BLOCK/M_DRV2P 2SC5200
R516 Net-_Q512-Pad2_ /POWER_AMP_BLOCK/M_FPSSP 10k
C602 Net-_C602-Pad1_ Net-_C602-Pad2_ 0.1uF
C601 Net-_C601-Pad1_ Net-_C601-Pad2_ 0.1uF
D509 M_VSWON /POWER_AMP_BLOCK/M_VBIASN 1N4004
D508 /POWER_AMP_BLOCK/M_VBIASP /POWER_AMP_BLOCK/M_VSWOP 1N4004
Q604 Net-_D611-Pad1_ Net-_D610-Pad1_ -42V 2N5401
D610 Net-_D610-Pad1_ Net-_D609-Pad2_ 1N4007
Q601 Net-_D604-Pad2_ Net-_D603-Pad2_ +42V 2N5551
D603 Net-_D602-Pad1_ Net-_D603-Pad2_ 1N4007
R622 Net-_D617-Pad2_ Net-_D603-Pad2_ 47k
D617 Net-_C603-Pad2_ Net-_D617-Pad2_ 1N4148
R621 +42V Net-_C603-Pad2_ 12k
D616 +42V Net-_C603-Pad2_ 1N4148
R624 Net-_D620-Pad1_ Net-_D610-Pad1_ 47k
D620 Net-_D620-Pad1_ Net-_C604-Pad2_ 1N4148
D619 Net-_C604-Pad2_ -42V 1N4148
R623 -42V Net-_C604-Pad2_ 12k
R608 Net-_D606-Pad1_ Net-_C601-Pad2_ 220
R607 Net-_D606-Pad1_ Net-_C601-Pad1_ 20k
R617 Net-_C602-Pad2_ Net-_D613-Pad2_ 220
R616 Net-_C602-Pad1_ Net-_D613-Pad2_ 20k
R618 -42V Net-_D613-Pad2_ 20k
R609 Net-_D606-Pad1_ +42V 20k
R503 0 Net-_Q503-Pad1_ 22k
R5041 Net-_Q503-Pad2_ -120V 150
R5042 Net-_Q503-Pad2_ -120V 680
R5021 +120V Net-_Q501-Pad2_ 150
R5022 +120V Net-_Q501-Pad2_ 680
R501 Net-_Q501-Pad1_ 0 22k
R5091 /POWER_AMP_BLOCK/M_DRV1P /POWER_AMP_BLOCK/M_DRV1N 120
R5092 /POWER_AMP_BLOCK/M_DRV1P /POWER_AMP_BLOCK/M_DRV1N 2.7k
R301 Net-_C301-Pad2_ 0 100k
C604 JH1 Net-_C604-Pad2_ 6.8nF
D618 JH1 M_VSWON 1N4148
C603 Net-_C603-Pad1_ Net-_C603-Pad2_ 6.8nF
R620 Net-_C603-Pad1_ JH1 47k
D615 /POWER_AMP_BLOCK/M_VSWOP Net-_C603-Pad1_ 1N4148
D602 Net-_D602-Pad1_ Net-_D601-Pad2_ 1N4004
D601 /POWER_AMP_BLOCK/M_OUT_RAW Net-_D601-Pad2_ 1N4738
D302 -120V Net-_D302-Pad2_ 1N4734
D301 Net-_D301-Pad1_ +120V 1N4734
XU302 /POWER_AMP_BLOCK/M_LMSON Net-_R311-Pad2_ Net-_R309-Pad2_ -15V Net-_R305-Pad2_ Net-_D303-Pad1_ /POWER_AMP_BLOCK/M_LMSOP +15V RC4558_IMPL
R302 Net-_R302-Pad1_ Net-_R302-Pad2_ 3.3k
XU301 Net-_R302-Pad1_ Net-_R302-Pad1_ Net-_C301-Pad2_ -15V Net-_R302-Pad2_ Net-_R303-Pad2_ Net-_C401-Pad1_ +15V RC4558_IMPL
D609 Net-_D608-Pad1_ Net-_D609-Pad2_ 1N4004
D608 Net-_D608-Pad1_ /POWER_AMP_BLOCK/M_OUT_RAW 1N4738
XLOC301 Net-_R314-Pad2_ LIMIT_IND_SRC Net-_R302-Pad2_ 0 NSL32SR3
Q301 LIMIT_IND_SRC Net-_D304-Pad2_ 0 2N5551
D304 0 Net-_D304-Pad2_ 1N4148
R314 +15V Net-_R314-Pad2_ 2.7k
R304 Net-_R303-Pad2_ 0 180k
R303 Net-_C401-Pad1_ Net-_R303-Pad2_ 1k
D303 Net-_D303-Pad1_ /POWER_AMP_BLOCK/M_LMSON 1N4148
C301 M_INPUT Net-_C301-Pad2_ 10uF
R313 /POWER_AMP_BLOCK/M_LMSOP Net-_D304-Pad2_ 15k
X6021 M_VSWON Net-_D613-Pad2_ -120V IRF540
R308 Net-_D303-Pad1_ 0 2.7k
R306 Net-_R305-Pad2_ 0 2.7k
R312 Net-_R311-Pad2_ 0 2.7k
R311 Net-_D302-Pad2_ Net-_R311-Pad2_ 100k
R309 /POWER_AMP_BLOCK/M_OUT_RAW Net-_R309-Pad2_ 100k
R307 Net-_D301-Pad1_ Net-_D303-Pad1_ 100k
R603 +120V Net-_D604-Pad2_ 15k
C702 /POWER_AMP_BLOCK/M_FPTH 0 10uF
R718 +15V Net-_Q704-Pad1_ 3.9k
R717 Net-_Q704-Pad3_ 0 5.6k
Q704 Net-_Q704-Pad1_ /POWER_AMP_BLOCK/M_FPTH Net-_Q704-Pad3_ 2N5551
Q705 +RLC Net-_Q704-Pad1_ +15V TIP42C
D708 -RLC +RLC 1N4002
R719 -RLC -15V 150
R713 +15V Net-_Q702-Pad2_ 2.2k
R712 Net-_Q702-Pad2_ Net-_R712-Pad2_ 2.7k
R715 /POWER_AMP_BLOCK/M_FPSO 0 12k
R714 Net-_Q702-Pad1_ /POWER_AMP_BLOCK/M_FPSO 15k
Q702 Net-_Q702-Pad1_ Net-_Q702-Pad2_ +15V 2N5401
R716 +15V /POWER_AMP_BLOCK/M_FPTH 82k
Q703 /POWER_AMP_BLOCK/M_FPTH /POWER_AMP_BLOCK/M_FPSO 0 2N5551
R711 Net-_D707-Pad1_ Net-_R711-Pad2_ 1k
XOC701 Net-_R711-Pad2_ /POWER_AMP_BLOCK/M_FPSSN 0 Net-_R712-Pad2_ PC817
D707 Net-_D707-Pad1_ /POWER_AMP_BLOCK/M_FPSSP 1N4732
R615 Net-_Q605-Pad1_ Net-_Q606-Pad2_ 3.9k
R614 -42V Net-_Q605-Pad1_ 68k
R606 Net-_Q602-Pad1_ Net-_Q603-Pad2_ 3.9k
R605 Net-_Q602-Pad1_ +42V 68k
R604 Net-_D604-Pad2_ Net-_Q602-Pad2_ 15k
R601 +120V Net-_D602-Pad1_ 47k
R602 Net-_D603-Pad2_ +42V 33k
R611 -42V Net-_D610-Pad1_ 33k
R610 Net-_D609-Pad2_ -120V 47k
R612 Net-_D611-Pad1_ -120V 15k
R613 Net-_D611-Pad1_ Net-_Q605-Pad2_ 15k
XU701 Net-_R702-Pad1_ Net-_R702-Pad2_ Net-_D701-Pad2_ -15V Net-_C701-Pad1_ Net-_R706-Pad2_ /POWER_AMP_BLOCK/M_FPODO +15V RC4558_IMPL
R702 Net-_R702-Pad1_ Net-_R702-Pad2_ 100k
R703 Net-_R702-Pad2_ 0 1k
R701 /POWER_AMP_BLOCK/M_OUT_RAW Net-_D701-Pad2_ 100k
C701 Net-_C701-Pad1_ 0 1uF
D702 Net-_D701-Pad2_ 0 1N4148
D706 Net-_D706-Pad1_ /POWER_AMP_BLOCK/M_FPODO 1N4148
D705 /POWER_AMP_BLOCK/M_FPODO Net-_D705-Pad2_ 1N4148
Q701 Net-_Q701-Pad1_ Net-_D705-Pad2_ Net-_D706-Pad1_ 2N5551
R709 Net-_D706-Pad1_ 0 2.7k
R708 0 Net-_D705-Pad2_ 2.7k
R710 Net-_Q701-Pad1_ Net-_Q702-Pad2_ 2.7k
X6011 /POWER_AMP_BLOCK/M_VSWOP Net-_D606-Pad1_ +120V IRF9540
X6012 /POWER_AMP_BLOCK/M_VSWOP Net-_D606-Pad1_ +120V IRF9540
R619 M_VSWON /POWER_AMP_BLOCK/M_VSWOP 47k
R520 /POWER_AMP_BLOCK/M_OUT_RAW Net-_C502-Pad1_ 10
D701 0 Net-_D701-Pad2_ 1N4148
R706 /POWER_AMP_BLOCK/M_FPODO Net-_R706-Pad2_ 10k
R707 Net-_R706-Pad2_ 0 10k
R402 Net-_C402-Pad2_ 0 22k
C402 0 Net-_C402-Pad2_ 470pF
C403 Net-_C403-Pad1_ 0 220uF
R4041 Net-_R4041-Pad1_ Net-_Q402-Pad2_ 270
C401 Net-_C401-Pad1_ Net-_C401-Pad2_ 220uF
D703 /POWER_AMP_BLOCK/M_FPODLO 0 1N4148
D704 0 /POWER_AMP_BLOCK/M_FPODLO 1N4148
R705 /POWER_AMP_BLOCK/M_FPODLO Net-_C701-Pad1_ 120k
R704 Net-_R702-Pad1_ /POWER_AMP_BLOCK/M_FPODLO 4.7k
Q401 Net-_C404-Pad1_ Net-_C402-Pad2_ Net-_Q401-Pad3_ 2N5551
Q402 +120V Net-_Q402-Pad2_ Net-_Q401-Pad3_ 2N5551
Q406 Net-_Q406-Pad1_ Net-_Q405-Pad1_ Net-_Q405-Pad2_ MJE340
Q405 Net-_Q405-Pad1_ Net-_Q405-Pad2_ -120V 2N5551
Q409 Net-_C404-Pad2_ Net-_C404-Pad1_ Net-_Q409-Pad3_ MJE350
Q408 Net-_Q408-Pad1_ Net-_Q407-Pad1_ Net-_Q407-Pad2_ MJE350
Q403 Net-_C405-Pad1_ Net-_C402-Pad2_ Net-_Q403-Pad3_ 2N5401
Q410 Net-_C404-Pad2_ Net-_C405-Pad1_ Net-_Q410-Pad3_ MJE340
C405 Net-_C405-Pad1_ Net-_C404-Pad2_ 120pF
R408 0 Net-_Q405-Pad1_ 22k
R411 0 Net-_Q407-Pad1_ 22k
R4141 Net-_Q410-Pad3_ -120V 150
R4131 +120V Net-_Q409-Pad3_ 150
R4091 Net-_Q405-Pad2_ -120V 150
R4121 +120V Net-_Q407-Pad2_ 150
R406 Net-_C405-Pad1_ -120V 470
R405 +120V Net-_C404-Pad1_ 470
R4092 Net-_Q405-Pad2_ -120V 680
R4122 +120V Net-_Q407-Pad2_ 680
R4142 Net-_Q410-Pad3_ -120V 750
R4132 +120V Net-_Q409-Pad3_ 750
C404 Net-_C404-Pad1_ Net-_C404-Pad2_ 120pF
R407 Net-_Q401-Pad3_ Net-_Q406-Pad1_ 270
Q404 -120V Net-_Q402-Pad2_ Net-_Q403-Pad3_ 2N5401
R410 Net-_Q408-Pad1_ Net-_Q403-Pad3_ 270
Q407 Net-_Q407-Pad1_ Net-_Q407-Pad2_ +120V 2N5401
R4012 Net-_R4011-Pad2_ Net-_C402-Pad2_ 2.0
R403 /POWER_AMP_BLOCK/M_OUT_RAW Net-_Q402-Pad2_ 22k
C302 LIMIT_IND_SRC 0 220uF
R310 Net-_R309-Pad2_ 0 2.7k
R305 /POWER_AMP_BLOCK/M_OUT_RAW Net-_R305-Pad2_ 100k
R4042 Net-_R4041-Pad1_ Net-_C403-Pad1_ 2.0
R4011 Net-_C401-Pad2_ Net-_R4011-Pad2_ 270
.end
